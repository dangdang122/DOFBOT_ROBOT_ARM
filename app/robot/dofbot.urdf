Commit message: Update 26-06-30

File: app/robot/dofbot.urdf (robot description, URDF)
Before this commit: robot dofbot, 7 links, 6 joints
Joints:
- joint gripper: origin xyz=0 0 0.11 -> xyz=0 0 0.135
